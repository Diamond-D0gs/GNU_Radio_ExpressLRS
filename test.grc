options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: elrs_module_elrs_receiver_0
  id: elrs_module_elrs_receiver
  parameters:
    binding_phrase: '"DefaultBindingPhrase"'
    domain: '"FCC915"'
    packet_rate: '1'
  states: {}
- name: elrs_module_elrs_transmitter_0
  id: elrs_module_elrs_transmitter
  parameters:
    binding_phrase: '"DefaultBindingPhrase"'
    domain: '"FCC915"'
    packet_rate: '1'
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: start
  states: {}

connections:
- [elrs_module_elrs_receiver_0, '0', elrs_module_elrs_transmitter_0, '0']
- [elrs_module_elrs_transmitter_0, '0', elrs_module_elrs_receiver_0, '0']
- [elrs_module_elrs_transmitter_0, start, virtual_sink_2, '0']

metadata:
  file_format: 1
