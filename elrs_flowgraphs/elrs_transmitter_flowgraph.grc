options:
  parameters:
    author: Gabriel Garcia
    generate_options: no_gui
    id: elrs_transmitter_flowgraph
    output_language: python
    title: ELRS Transmitter Flowgraph
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: binding_phrase
  id: variable
  parameters:
    value: '"TestBindingPhrase"'
  states: {}
- name: counter
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: disable
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: freq_center
  id: variable
  parameters:
    value: '914700000'
  states: {}
- name: freq_count
  id: variable
  parameters:
    value: '20'
  states: {}
- name: freq_start
  id: variable
  parameters:
    value: freq_center - (wide_samp_rate // 2)
  states: {}
- name: freq_stop
  id: variable
  parameters:
    value: freq_center + (wide_samp_rate // 2)
  states: {}
- name: freq_temp
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bandwidth*2
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: 926900000 - 903500000
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("")
    period: 1000 // 25
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  current_freq_index = self.freq_sequence[self.fhss_index]
                  absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                  freq_offset = absolute_freq - self.freq_center

                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)
                  
                  self.fhss_index = (self.fhss_index + 1) % self.freq_count
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)


          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import time
      import ctypes
      import numpy as np
      from hashlib import md5
      from gnuradio import gr
      from pathlib import Path
      from typing import Optional, TextIO

      class Crc2Byte:
          _CRCTAB_LEN = 256

          def __init__(self, bits: int, poly: int):
              if not (8 <= bits <= 16):
                  raise ValueError("CRC bit-width must be between 8 and 16.")

              self.bits = bits
              self.poly = poly
              self.bitmask = (1 << self.bits) - 1
              
              # Pre-compute the CRC lookup table
              self.crctab = self._generate_table()

          def _generate_table(self) -> list[int]:
              crctab = [0] * self._CRCTAB_LEN
              highbit = 1 << (self.bits - 1)

              for i in range(self._CRCTAB_LEN):
                  crc = i << (self.bits - 8)
                  for _ in range(8):
                      if crc & highbit:
                          crc = (crc << 1) ^ self.poly
                      else:
                          crc = crc << 1
                  crctab[i] = crc & self.bitmask
              return crctab

          def calc(self, data: bytes, initial_crc: int = 0) -> int:
              crc = initial_crc

              for byte in data:
                  lookup_index = ((crc >> (self.bits - 8)) ^ byte) & 0xFF
                  crc = (crc << 8) ^ self.crctab[lookup_index]

              return crc & self.bitmask

      # The final, top-level packet structure
      class OTA_Packet4_s(ctypes.Structure):
          """
          Main packet structure corresponding to OTA_Packet4_s.
          """
          _pack_ = 1
          _fields_ = [
              # First byte: type and crcHigh
              ("type", ctypes.c_uint8, 2),
              ("crcHigh", ctypes.c_uint8, 6),
              # Main payload union (6 bytes)
              ("payload", ctypes.c_uint8 * 6),
              # Last byte: crcLow
              ("crcLow", ctypes.c_uint8),
          ]

      class elrs_transmitter_data_gen(gr.sync_block):
          """
          Receives a trigger message. On each trigger, it formats a string
          with the value of a 'counter' variable from the top_block,
          sends it as a new message, and increments the counter.
          """
          def __init__(self, bindingPhrase: str='DefaultBindingPhrase', filepath: str='', loopFile:bool =False):
              gr.sync_block.__init__(self,
                  name='ELRS Transmitter Data Gen',
                  in_sig=None,
                  out_sig=None)
              
              self.filepath_str = filepath
              self.filepath = Path(filepath)
              self.file: Optional[TextIO] = None
              self.crc_calc = Crc2Byte(16, 0x3D65)
              self.loop_file: bool = loopFile
              self.done: bool = False

              self.packet_datas: list[bytes] = []
              self.packet_datas_pos = 0

              uid = md5(str(f'-DMY_BINDING_PHRASE="{bindingPhrase}"').encode('utf-8')).digest()[:6]
              self.ota_crc = ((uid[4] << 8) | uid[5]) ^ 4
              
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

          def handle_msg(self, msg):
              if not self.done:
                  # 1. Read current payload
                  curr_bytes = self.packet_datas[self.packet_datas_pos][:6]
                  self.packet_datas_pos += 1
                  if self.packet_datas_pos == len(self.packet_datas):
                      if self.loop_file:
                          self.packet_datas_pos = 0
                      else:
                          self.done = True

                  # 2. Calculate CRC
                  crc = self.crc_calc.calc(curr_bytes, self.ota_crc)
                  
                  # 3. Convert hex byte stream to bytearray
                  backing_buffer = bytearray(ctypes.sizeof(OTA_Packet4_s))
                  ota_packet = OTA_Packet4_s.from_buffer(backing_buffer)
                  ota_packet.crcHigh = crc >> 8
                  ota_packet.crcLow = crc & 0xFF
                  ota_packet.payload[:] = curr_bytes

                  # 4. Create the new PMT message
                  output_msg = pmt.init_u8vector(len(backing_buffer), backing_buffer)

                  # 5. Publish the new message
                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def start(self) -> bool:
              if not self.filepath.is_file():
                  print(f'ELRS Transmitter Data Gen: \'{self.filepath_str}\' is not a valid filepath!')
                  return False
              
              try:
                  with open(self.filepath, 'r', encoding='utf-8') as file:
                      curr_line = file.readline()
                      while len(curr_line) != 0:
                          self.packet_datas.append(bytes.fromhex(curr_line))
                          curr_line = file.readline()
              except Exception as e:
                  print('ELRS Transmitter Data Gen: Exception occured while trying to open file.\n', e)
                  return False

              return True

          def stop(self) -> bool:
              return True

          def work(self, input_items, output_items):
              # This block only processes messages, so work() does nothing.
              return 0
    bindingPhrase: binding_phrase
    filepath: '''/home/gabriel/GNU_Radio_ExpressLRS/test.txt'''
    loopFile: 'True'
  states: {}
- name: lora_sdr_lora_tx_mod_0
  id: lora_sdr_lora_tx_mod
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '128'
    has_crc: 'False'
    impl_head: 'True'
    ldro: '0'
    samp_rate: int(samp_rate)
    sf: sf
    sync_word: '[0x12]'
  states: {}
- name: network_udp_sink_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '1234'
    send_eof: 'False'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.0'
    interp: '448'
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_message_strobe_0, strobe, epy_block_0, msg_in]
- [blocks_message_strobe_0, strobe, epy_block_2, msg_in]
- [blocks_multiply_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_xx_0, '0', network_udp_sink_1, '0']
- [epy_block_0, msg_out, blocks_msgpair_to_var_0, inpair]
- [epy_block_2, msg_out, lora_sdr_lora_tx_mod_0, in]
- [lora_sdr_lora_tx_mod_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
