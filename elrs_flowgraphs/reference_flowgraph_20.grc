options:
  parameters:
    generate_options: qt_gui
    id: elrs_transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: binding_phrase
  id: variable
  parameters:
    value: '"TestBindingPhrase"'
  states: {}
- name: counter
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: disable
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: freq_center
  id: variable
  parameters:
    value: '914700000'
  states: {}
- name: freq_count
  id: variable
  parameters:
    value: '40'
  states: {}
- name: freq_start
  id: variable
  parameters:
    value: freq_center - (wide_samp_rate // 2)
  states: {}
- name: freq_stop
  id: variable
  parameters:
    value: freq_center + (wide_samp_rate // 2)
  states: {}
- name: freq_temp
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_1
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_10
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_11
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_12
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_13
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_14
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_2
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_3
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_4
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_5
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_6
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_7
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_8
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: freq_temp_9
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bandwidth*2
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: 926900000 - 903500000
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp_1 - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp - 3.7e3
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/gabriel/GNU_Radio_ExpressLRS/results/elrs_0
    type: byte
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("")
    period: 1000 // 50
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_1
  states: {}
- name: blocks_msgpair_to_var_0_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_2
  states: {}
- name: blocks_msgpair_to_var_0_0_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_3
  states: {}
- name: blocks_msgpair_to_var_0_0_0_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_4
  states: {}
- name: blocks_msgpair_to_var_0_0_0_0_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_9
  states: {}
- name: blocks_msgpair_to_var_0_0_0_0_0_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_14
  states: {}
- name: blocks_msgpair_to_var_0_0_0_0_1
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_8
  states: {}
- name: blocks_msgpair_to_var_0_0_0_0_1_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_13
  states: {}
- name: blocks_msgpair_to_var_0_0_0_1
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_7
  states: {}
- name: blocks_msgpair_to_var_0_0_0_1_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_12
  states: {}
- name: blocks_msgpair_to_var_0_0_1
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_6
  states: {}
- name: blocks_msgpair_to_var_0_0_1_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_11
  states: {}
- name: blocks_msgpair_to_var_0_1
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_5
  states: {}
- name: blocks_msgpair_to_var_0_1_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp_10
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.num_primary_bands
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index += 1
                      self.fhss_index %= self.num_primary_bands

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "0"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "1"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "6"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "11"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "2"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "7"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_1_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "12"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "3"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_2_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "8"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_2_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "13"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_3
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "4"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_3_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "9"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_3_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index = (self.fhss_index + 1) % self.freq_count

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "14"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_4
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.num_primary_bands
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index += 1
                      self.fhss_index %= self.num_primary_bands

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "5"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_0_4_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable
              self.switch = False

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.num_primary_bands
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  if self.switch:
                      current_freq_index = self.freq_sequence[self.fhss_index]
                      absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                      freq_offset = absolute_freq - self.freq_center

                      key = pmt.intern("freq_temp")
                      value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                      output_msg = pmt.cons(key, value)

                      self.message_port_pub(pmt.intern("msg_out"), output_msg)
                      
                      self.fhss_index += 1
                      self.fhss_index %= self.num_primary_bands

                  self.switch = not self.switch
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase + "10"
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr

      class counter_formatter(gr.sync_block):
          """
          Receives a trigger message. On each trigger, it formats a string
          with the value of a 'counter' variable from the top_block,
          sends it as a new message, and increments the counter.
          """
          def __init__(self, packet_count: int = 999):
              gr.sync_block.__init__(self,
                  name='Counter Formatter',
                  in_sig=None,
                  out_sig=None)

              self.counter = 0
              self.packet_count = packet_count
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

          def handle_msg(self, msg):
              if self.counter < self.packet_count:
                  # 1. Format the string using the flowgraph's 'counter' variable
                  # Note: self.counter works because the 'counter' Variable block
                  # creates a 'self.counter' attribute on the main flowgraph class.
                  payload_str = str(f'{self.counter:05d}\n')

                  # 2. Create the new PMT message
                  output_msg = pmt.intern(payload_str)

                  # 3. Publish the new message
                  self.message_port_pub(pmt.intern("msg_out"), output_msg)
                  
                  # 4. Increment the counter for the next time
                  self.counter += 1
                  if self.counter == self.packet_count:
                      print('Counter Formatter: Done.')

          def work(self, input_items, output_items):
              # This block only processes messages, so work() does nothing.
              return 0
    packet_count: '2000'
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '0'
    pay_len: '6'
    print_rx: '[True,True]'
    samp_rate: int(samp_rate)
    sf: '7'
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0_0
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0_0_0
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0_0_0_0
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0_0_0_0_0
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0_0_0_0_0_0
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0_0_0_1
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0_0_0_1_0
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0_0_1
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0_0_1_0
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0_1
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_0_1_0
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_1
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0_1_0
  id: lora_tx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'True'
    ldro: '2'
    samp_rate: int(samp_rate)
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: freq_stop - freq_start
    fc: (freq_stop + freq_start) / 2
    fftsize: '512'
    int_max: '0'
    type: complex
    update_time: '0.01'
    wintype: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '448'
    fbw: '0.04'
    interp: '5'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.04'
    interp: '448'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_2
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_3
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_4
  states: {}
- name: virtual_sink_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_9
  states: {}
- name: virtual_sink_0_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_14
  states: {}
- name: virtual_sink_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_8
  states: {}
- name: virtual_sink_0_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_13
  states: {}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_7
  states: {}
- name: virtual_sink_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_12
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_6
  states: {}
- name: virtual_sink_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_11
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_5
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora_10
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: message
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: shift_source_0
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: shift_source_1
  states: {}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: shift_source_2
  states: {}
- name: virtual_sink_2_0_0_0
  id: virtual_sink
  parameters:
    stream_id: shift_source_3
  states: {}
- name: virtual_sink_2_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: shift_source_4
  states: {}
- name: virtual_sink_2_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: shift_source_9
  states: {}
- name: virtual_sink_2_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: shift_source_14
  states: {}
- name: virtual_sink_2_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: shift_source_8
  states: {}
- name: virtual_sink_2_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: shift_source_13
  states: {}
- name: virtual_sink_2_0_0_1
  id: virtual_sink
  parameters:
    stream_id: shift_source_7
  states: {}
- name: virtual_sink_2_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: shift_source_12
  states: {}
- name: virtual_sink_2_0_1
  id: virtual_sink
  parameters:
    stream_id: shift_source_6
  states: {}
- name: virtual_sink_2_0_1_0
  id: virtual_sink
  parameters:
    stream_id: shift_source_11
  states: {}
- name: virtual_sink_2_1
  id: virtual_sink
  parameters:
    stream_id: shift_source_5
  states: {}
- name: virtual_sink_2_1_0
  id: virtual_sink
  parameters:
    stream_id: shift_source_10
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_0
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_1
  states: {}
- name: virtual_sink_3_0_0
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_2
  states: {}
- name: virtual_sink_3_0_0_0
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_3
  states: {}
- name: virtual_sink_3_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_4
  states: {}
- name: virtual_sink_3_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_9
  states: {}
- name: virtual_sink_3_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_14
  states: {}
- name: virtual_sink_3_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_8
  states: {}
- name: virtual_sink_3_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_13
  states: {}
- name: virtual_sink_3_0_0_1
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_7
  states: {}
- name: virtual_sink_3_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_12
  states: {}
- name: virtual_sink_3_0_1
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_6
  states: {}
- name: virtual_sink_3_0_1_0
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_11
  states: {}
- name: virtual_sink_3_1
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_5
  states: {}
- name: virtual_sink_3_1_0
  id: virtual_sink
  parameters:
    stream_id: shifted_lora_10
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: combined_0
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: combined
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_2
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_3
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_4
  states: {}
- name: virtual_source_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_9
  states: {}
- name: virtual_source_0_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_14
  states: {}
- name: virtual_source_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_8
  states: {}
- name: virtual_source_0_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_13
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_7
  states: {}
- name: virtual_source_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_12
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_6
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_11
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_5
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora_10
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0_0_1
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0_1
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: shift_source_0
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: shift_source_1
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: shift_source_2
  states: {}
- name: virtual_source_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: shift_source_3
  states: {}
- name: virtual_source_2_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: shift_source_4
  states: {}
- name: virtual_source_2_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: shift_source_9
  states: {}
- name: virtual_source_2_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: shift_source_14
  states: {}
- name: virtual_source_2_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: shift_source_8
  states: {}
- name: virtual_source_2_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: shift_source_13
  states: {}
- name: virtual_source_2_0_0_1
  id: virtual_source
  parameters:
    stream_id: shift_source_7
  states: {}
- name: virtual_source_2_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: shift_source_12
  states: {}
- name: virtual_source_2_0_1
  id: virtual_source
  parameters:
    stream_id: shift_source_6
  states: {}
- name: virtual_source_2_0_1_0
  id: virtual_source
  parameters:
    stream_id: shift_source_11
  states: {}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: shift_source_5
  states: {}
- name: virtual_source_2_1_0
  id: virtual_source
  parameters:
    stream_id: shift_source_10
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: shifted_lora_5
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: shifted_lora_6
  states: {}
- name: virtual_source_3_0_0
  id: virtual_source
  parameters:
    stream_id: shifted_lora_7
  states: {}
- name: virtual_source_3_0_0_0
  id: virtual_source
  parameters:
    stream_id: shifted_lora_8
  states: {}
- name: virtual_source_3_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: shifted_lora_9
  states: {}
- name: virtual_source_3_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: shifted_lora_4
  states: {}
- name: virtual_source_3_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: combined_0
  states: {}
- name: virtual_source_3_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: shifted_lora_14
  states: {}
- name: virtual_source_3_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: shifted_lora_3
  states: {}
- name: virtual_source_3_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: shifted_lora_13
  states: {}
- name: virtual_source_3_0_0_1
  id: virtual_source
  parameters:
    stream_id: shifted_lora_2
  states: {}
- name: virtual_source_3_0_0_2
  id: virtual_source
  parameters:
    stream_id: shifted_lora_12
  states: {}
- name: virtual_source_3_0_1
  id: virtual_source
  parameters:
    stream_id: shifted_lora_1
  states: {}
- name: virtual_source_3_0_2
  id: virtual_source
  parameters:
    stream_id: shifted_lora_11
  states: {}
- name: virtual_source_3_1
  id: virtual_source
  parameters:
    stream_id: shifted_lora_0
  states: {}
- name: virtual_source_3_2
  id: virtual_source
  parameters:
    stream_id: shifted_lora_10
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: combined
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: shift_source_0
  states: {}

connections:
- [analog_sig_source_x_0, '0', virtual_sink_2, '0']
- [analog_sig_source_x_0_0, '0', virtual_sink_2_0, '0']
- [analog_sig_source_x_0_0_0, '0', virtual_sink_2_0_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', virtual_sink_2_0_0_0, '0']
- [analog_sig_source_x_0_0_0_0_0, '0', virtual_sink_2_0_0_0_0, '0']
- [analog_sig_source_x_0_0_0_0_0_0, '0', virtual_sink_2_0_0_0_0_0, '0']
- [analog_sig_source_x_0_0_0_0_0_0_0, '0', virtual_sink_2_0_0_0_0_0_0, '0']
- [analog_sig_source_x_0_0_0_0_1, '0', virtual_sink_2_0_0_0_1, '0']
- [analog_sig_source_x_0_0_0_0_1_0, '0', virtual_sink_2_0_0_0_1_0, '0']
- [analog_sig_source_x_0_0_0_1, '0', virtual_sink_2_0_0_1, '0']
- [analog_sig_source_x_0_0_0_1_0, '0', virtual_sink_2_0_0_1_0, '0']
- [analog_sig_source_x_0_0_1, '0', virtual_sink_2_0_1, '0']
- [analog_sig_source_x_0_0_1_0, '0', virtual_sink_2_0_1_0, '0']
- [analog_sig_source_x_0_1, '0', virtual_sink_2_1, '0']
- [analog_sig_source_x_0_1_0, '0', virtual_sink_2_1_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_4, '0']
- [blocks_add_xx_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_add_xx_0_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0_0_0, '0', virtual_sink_4_0, '0']
- [blocks_add_xx_0_1, '0', blocks_add_xx_0_0_0, '2']
- [blocks_divide_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_1, msg_in]
- [blocks_multiply_xx_0, '0', virtual_sink_3, '0']
- [blocks_multiply_xx_0_0, '0', virtual_sink_3_0, '0']
- [blocks_multiply_xx_0_0_0, '0', virtual_sink_3_0_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', virtual_sink_3_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0, '0', virtual_sink_3_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0_0, '0', virtual_sink_3_0_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0_0_0, '0', virtual_sink_3_0_0_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_1, '0', virtual_sink_3_0_0_0_1, '0']
- [blocks_multiply_xx_0_0_0_0_1_0, '0', virtual_sink_3_0_0_0_1_0, '0']
- [blocks_multiply_xx_0_0_0_1, '0', virtual_sink_3_0_0_1, '0']
- [blocks_multiply_xx_0_0_0_1_0, '0', virtual_sink_3_0_0_1_0, '0']
- [blocks_multiply_xx_0_0_1, '0', virtual_sink_3_0_1, '0']
- [blocks_multiply_xx_0_0_1_0, '0', virtual_sink_3_0_1_0, '0']
- [blocks_multiply_xx_0_1, '0', virtual_sink_3_1, '0']
- [blocks_multiply_xx_0_1_0, '0', virtual_sink_3_1_0, '0']
- [epy_block_0, msg_out, blocks_msgpair_to_var_0, inpair]
- [epy_block_0_0, msg_out, blocks_msgpair_to_var_0_0, inpair]
- [epy_block_0_0_0, msg_out, blocks_msgpair_to_var_0_0_1, inpair]
- [epy_block_0_0_0_0, msg_out, blocks_msgpair_to_var_0_0_1_0, inpair]
- [epy_block_0_1, msg_out, blocks_msgpair_to_var_0_0_0, inpair]
- [epy_block_0_1_0, msg_out, blocks_msgpair_to_var_0_0_0_1, inpair]
- [epy_block_0_1_0_0, msg_out, blocks_msgpair_to_var_0_0_0_1_0, inpair]
- [epy_block_0_2, msg_out, blocks_msgpair_to_var_0_0_0_0, inpair]
- [epy_block_0_2_0, msg_out, blocks_msgpair_to_var_0_0_0_0_1, inpair]
- [epy_block_0_2_0_0, msg_out, blocks_msgpair_to_var_0_0_0_0_1_0, inpair]
- [epy_block_0_3, msg_out, blocks_msgpair_to_var_0_0_0_0_0, inpair]
- [epy_block_0_3_0, msg_out, blocks_msgpair_to_var_0_0_0_0_0_0, inpair]
- [epy_block_0_3_0_0, msg_out, blocks_msgpair_to_var_0_0_0_0_0_0_0, inpair]
- [epy_block_0_4, msg_out, blocks_msgpair_to_var_0_1, inpair]
- [epy_block_0_4_0, msg_out, blocks_msgpair_to_var_0_1_0, inpair]
- [epy_block_1, msg_out, virtual_sink_1, '0']
- [lora_rx_0, '0', blocks_file_sink_0, '0']
- [lora_tx_0, '0', virtual_sink_0, '0']
- [lora_tx_0_0, '0', virtual_sink_0_0, '0']
- [lora_tx_0_0_0, '0', virtual_sink_0_0_0, '0']
- [lora_tx_0_0_0_0, '0', virtual_sink_0_0_0_0, '0']
- [lora_tx_0_0_0_0_0, '0', virtual_sink_0_0_0_0_0, '0']
- [lora_tx_0_0_0_0_0_0, '0', virtual_sink_0_0_0_0_0_0, '0']
- [lora_tx_0_0_0_0_0_0_0, '0', virtual_sink_0_0_0_0_0_0_0, '0']
- [lora_tx_0_0_0_0_1, '0', virtual_sink_0_0_0_0_1, '0']
- [lora_tx_0_0_0_0_1_0, '0', virtual_sink_0_0_0_0_1_0, '0']
- [lora_tx_0_0_0_1, '0', virtual_sink_0_0_0_1, '0']
- [lora_tx_0_0_0_1_0, '0', virtual_sink_0_0_0_1_0, '0']
- [lora_tx_0_0_1, '0', virtual_sink_0_0_1, '0']
- [lora_tx_0_0_1_0, '0', virtual_sink_0_0_1_0, '0']
- [lora_tx_0_1, '0', virtual_sink_0_1, '0']
- [lora_tx_0_1_0, '0', virtual_sink_0_1_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', lora_rx_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_0_1_0, '0', blocks_multiply_xx_0_0_0, '0']
- [rational_resampler_xxx_0_1_0_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [rational_resampler_xxx_0_1_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_1_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_1_0_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_1_0_0_1, '0', blocks_multiply_xx_0_0_0_0_1, '0']
- [rational_resampler_xxx_0_1_0_0_1_0, '0', blocks_multiply_xx_0_0_0_0_1_0, '0']
- [rational_resampler_xxx_0_1_0_1, '0', blocks_multiply_xx_0_0_0_1, '0']
- [rational_resampler_xxx_0_1_0_1_0, '0', blocks_multiply_xx_0_0_0_1_0, '0']
- [rational_resampler_xxx_0_1_1, '0', blocks_multiply_xx_0_0_1, '0']
- [rational_resampler_xxx_0_1_1_0, '0', blocks_multiply_xx_0_0_1_0, '0']
- [rational_resampler_xxx_0_2, '0', blocks_multiply_xx_0_1, '0']
- [rational_resampler_xxx_0_2_0, '0', blocks_multiply_xx_0_1_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0_0, '0', rational_resampler_xxx_0_1, '0']
- [virtual_source_0_0_0, '0', rational_resampler_xxx_0_1_0, '0']
- [virtual_source_0_0_0_0, '0', rational_resampler_xxx_0_1_0_0, '0']
- [virtual_source_0_0_0_0_0, '0', rational_resampler_xxx_0_1_0_0_0, '0']
- [virtual_source_0_0_0_0_0_0, '0', rational_resampler_xxx_0_1_0_0_0_0, '0']
- [virtual_source_0_0_0_0_0_0_0, '0', rational_resampler_xxx_0_1_0_0_0_0_0, '0']
- [virtual_source_0_0_0_0_1, '0', rational_resampler_xxx_0_1_0_0_1, '0']
- [virtual_source_0_0_0_0_1_0, '0', rational_resampler_xxx_0_1_0_0_1_0, '0']
- [virtual_source_0_0_0_1, '0', rational_resampler_xxx_0_1_0_1, '0']
- [virtual_source_0_0_0_1_0, '0', rational_resampler_xxx_0_1_0_1_0, '0']
- [virtual_source_0_0_1, '0', rational_resampler_xxx_0_1_1, '0']
- [virtual_source_0_0_1_0, '0', rational_resampler_xxx_0_1_1_0, '0']
- [virtual_source_0_1, '0', rational_resampler_xxx_0_2, '0']
- [virtual_source_0_1_0, '0', rational_resampler_xxx_0_2_0, '0']
- [virtual_source_1, '0', epy_block_0, msg_in]
- [virtual_source_1, '0', lora_tx_0, in]
- [virtual_source_1_0, '0', epy_block_0_0, msg_in]
- [virtual_source_1_0, '0', lora_tx_0_0, in]
- [virtual_source_1_0_0, '0', epy_block_0_1, msg_in]
- [virtual_source_1_0_0, '0', lora_tx_0_0_0, in]
- [virtual_source_1_0_0_0, '0', epy_block_0_2, msg_in]
- [virtual_source_1_0_0_0, '0', lora_tx_0_0_0_0, in]
- [virtual_source_1_0_0_0_0, '0', epy_block_0_3, msg_in]
- [virtual_source_1_0_0_0_0, '0', lora_tx_0_0_0_0_0, in]
- [virtual_source_1_0_0_0_0_0, '0', epy_block_0_3_0, msg_in]
- [virtual_source_1_0_0_0_0_0, '0', lora_tx_0_0_0_0_0_0, in]
- [virtual_source_1_0_0_0_0_0_0, '0', epy_block_0_3_0_0, msg_in]
- [virtual_source_1_0_0_0_0_0_0, '0', lora_tx_0_0_0_0_0_0_0, in]
- [virtual_source_1_0_0_0_1, '0', epy_block_0_2_0, msg_in]
- [virtual_source_1_0_0_0_1, '0', lora_tx_0_0_0_0_1, in]
- [virtual_source_1_0_0_0_1_0, '0', epy_block_0_2_0_0, msg_in]
- [virtual_source_1_0_0_0_1_0, '0', lora_tx_0_0_0_0_1_0, in]
- [virtual_source_1_0_0_1, '0', epy_block_0_1_0, msg_in]
- [virtual_source_1_0_0_1, '0', lora_tx_0_0_0_1, in]
- [virtual_source_1_0_0_1_0, '0', epy_block_0_1_0_0, msg_in]
- [virtual_source_1_0_0_1_0, '0', lora_tx_0_0_0_1_0, in]
- [virtual_source_1_0_1, '0', epy_block_0_0_0, msg_in]
- [virtual_source_1_0_1, '0', lora_tx_0_0_1, in]
- [virtual_source_1_0_1_0, '0', epy_block_0_0_0_0, msg_in]
- [virtual_source_1_0_1_0, '0', lora_tx_0_0_1_0, in]
- [virtual_source_1_1, '0', epy_block_0_4, msg_in]
- [virtual_source_1_1, '0', lora_tx_0_1, in]
- [virtual_source_1_1_0, '0', epy_block_0_4_0, msg_in]
- [virtual_source_1_1_0, '0', lora_tx_0_1_0, in]
- [virtual_source_2, '0', blocks_multiply_xx_0, '1']
- [virtual_source_2_0, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_2_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [virtual_source_2_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [virtual_source_2_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '1']
- [virtual_source_2_0_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '1']
- [virtual_source_2_0_0_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0_0_0, '1']
- [virtual_source_2_0_0_0_1, '0', blocks_multiply_xx_0_0_0_0_1, '1']
- [virtual_source_2_0_0_0_1_0, '0', blocks_multiply_xx_0_0_0_0_1_0, '1']
- [virtual_source_2_0_0_1, '0', blocks_multiply_xx_0_0_0_1, '1']
- [virtual_source_2_0_0_1_0, '0', blocks_multiply_xx_0_0_0_1_0, '1']
- [virtual_source_2_0_1, '0', blocks_multiply_xx_0_0_1, '1']
- [virtual_source_2_0_1_0, '0', blocks_multiply_xx_0_0_1_0, '1']
- [virtual_source_2_1, '0', blocks_multiply_xx_0_1, '1']
- [virtual_source_2_1_0, '0', blocks_multiply_xx_0_1_0, '1']
- [virtual_source_3, '0', blocks_add_xx_0, '0']
- [virtual_source_3_0, '0', blocks_add_xx_0, '1']
- [virtual_source_3_0_0, '0', blocks_add_xx_0, '2']
- [virtual_source_3_0_0_0, '0', blocks_add_xx_0, '3']
- [virtual_source_3_0_0_0_0, '0', blocks_add_xx_0, '4']
- [virtual_source_3_0_0_0_0_0, '0', blocks_add_xx_0_0, '4']
- [virtual_source_3_0_0_0_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [virtual_source_3_0_0_0_0_1, '0', blocks_add_xx_0_1, '4']
- [virtual_source_3_0_0_0_1, '0', blocks_add_xx_0_0, '3']
- [virtual_source_3_0_0_0_2, '0', blocks_add_xx_0_1, '3']
- [virtual_source_3_0_0_1, '0', blocks_add_xx_0_0, '2']
- [virtual_source_3_0_0_2, '0', blocks_add_xx_0_1, '2']
- [virtual_source_3_0_1, '0', blocks_add_xx_0_0, '1']
- [virtual_source_3_0_2, '0', blocks_add_xx_0_1, '1']
- [virtual_source_3_1, '0', blocks_add_xx_0_0, '0']
- [virtual_source_3_2, '0', blocks_add_xx_0_1, '0']
- [virtual_source_4, '0', blocks_divide_xx_0, '0']
- [virtual_source_5, '0', blocks_divide_xx_0, '1']

metadata:
  file_format: 1
