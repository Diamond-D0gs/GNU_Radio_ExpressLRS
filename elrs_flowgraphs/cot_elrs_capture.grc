options:
  parameters:
    author: gabriel
    generate_options: qt_gui
    id: cot_elrs_capture
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '61440000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: 926900000 - 903500000
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '915000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'False'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 0.915e9
    fftsize: '512'
    type: complex
    update_time: '0.001'
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
