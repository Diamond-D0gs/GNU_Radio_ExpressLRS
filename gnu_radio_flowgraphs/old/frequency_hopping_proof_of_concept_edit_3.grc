options:
  parameters:
    generate_options: qt_gui
    id: elrs_transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 125000 * 1
  states: {}
- name: binding_phrase
  id: variable
  parameters:
    value: '"TestBindingPhrase"'
  states: {}
- name: counter
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: disable
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: freq_center
  id: variable
  parameters:
    value: (freq_stop + freq_start) / 2
  states: {}
- name: freq_count
  id: variable
  parameters:
    value: '40'
  states: {}
- name: freq_start
  id: variable
  parameters:
    value: '903500000'
  states: {}
- name: freq_stop
  id: variable
  parameters:
    value: '925900000'
  states: {}
- name: freq_temp
  id: variable
  parameters:
    value: freq_center
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bandwidth*2
  states: {}
- name: sdr_buffer_size
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: freq_stop - freq_start
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("")
    period: '1000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  current_freq_index = self.freq_sequence[self.fhss_index]
                  absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
              else:
                  absolute_freq = self.freq_center

              key = pmt.intern("freq")
              value = pmt.from_double(absolute_freq)
              output_msg = pmt.cons(key, value)

              self.message_port_pub(pmt.intern("msg_out"), output_msg)
                  
              if not self.disable:
                  self.fhss_index = (self.fhss_index + 1) % self.freq_count

              print(f"\nCurrent frequency: {int(absolute_freq)}")

          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr

      class counter_formatter(gr.sync_block):
          """
          Receives a trigger message. On each trigger, it formats a string
          with the value of a 'counter' variable from the top_block,
          sends it as a new message, and increments the counter.
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                  name='Counter Formatter',
                  in_sig=None,
                  out_sig=None)

              self.counter = 0
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Format the string using the flowgraph's 'counter' variable
              # Note: self.counter works because the 'counter' Variable block
              # creates a 'self.counter' attribute on the main flowgraph class.
              payload_str = "TEST " + str(self.counter)

              # 2. Create the new PMT message
              output_msg = pmt.intern(payload_str)

              # 3. Publish the new message
              self.message_port_pub(pmt.intern("msg_out"), output_msg)
              
              # 4. Increment the counter for the next time
              self.counter += 1

          def work(self, input_items, output_items):
              # This block only processes messages, so work() does nothing.
              return 0
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Custom block to create tx_freq tags from messages.
          This block receives a data stream and asynchronous messages.
          When a 'freq' message arrives, it adds a 'tx_freq' tag
          to the next sample on the output stream.
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Custom Message Tagger',
                  in_sig=[np.complex64],  # Expecting complex data stream in
                  out_sig=[np.complex64] # Outputting complex data stream
              )
              # Register the message input port
              self.message_port_register_in(pmt.intern('msg_in'))
              # Set the function that will handle incoming messages
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

              # A variable to hold the frequency from a received message
              self.next_freq_to_tag = None

          def handle_msg(self, msg):
              # This function is called by GNU Radio when a message arrives
              # Check if the message is the correct format (a pair)
              if pmt.is_pair(msg):
                  # The key is in the 'car' of the pair, value in the 'cdr'
                  key = pmt.car(msg)
                  if pmt.to_python(key) == 'freq':
                      # Store the frequency value. It will be used in the work() function.
                      self.next_freq_to_tag = pmt.cdr(msg)

          def work(self, input_items, output_items):
              # The main processing function for the data stream

              # Check if our message handler has stored a new frequency
              if self.next_freq_to_tag is not None:
                  # We have a frequency, so create a tag for it.
                  # The PlutoSDR Sink requires the key to be "tx_freq".
                  key = pmt.intern("tx_freq")
                  value = self.next_freq_to_tag

                  # Add the tag to the very first sample of this output buffer (index 0)
                  self.add_item_tag(0, # Port 0
                                    self.nitems_written(0), # Absolute index of the first item
                                    key,
                                    value)
                  
                  # Reset the variable so we don't add this tag again until a new message arrives
                  self.next_freq_to_tag = None

              # Copy the data from the input to the output
              # This block doesn't modify the data, it just passes it through
              output_items[0][:] = input_items[0]
              
              # Tell GNU Radio how many items we produced
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Takes a message pair ('freq': 123.45) and converts it
          to a dictionary {'freq': 123.45} for the Soapy Sink command port.
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Pair to Soapy CMD',
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('cmd_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  # The key for the Soapy Sink frequency setting is 'freq'
                  key = pmt.intern("freq")
                  value = pmt.cdr(msg)

                  # Create an empty dictionary
                  cmd_dict = pmt.make_dict()
                  # Add our key-value pair
                  cmd_dict = pmt.dict_add(cmd_dict, key, value)

                  # Publish the dictionary to the output port
                  self.message_port_pub(pmt.intern('cmd_out'), cmd_dict)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '50.0'
    bandwidth: '200000'
    buffer_size: sdr_buffer_size
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq_temp)
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(wide_samp_rate)
    bbdc: 'True'
    buffer_size: sdr_buffer_size
    filter_source: '''Auto'''
    frequency: int(freq_center)
    gain1: '''manual'''
    manual_gain1: '30'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(1e6)
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: crc
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: crc
    impl_head: 'False'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: '0'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bandwidth
    frame_zero_padd: int(20*2**sf*samp_rate/bandwidth)
    preamb_len: '8'
    samp_rate: samp_rate
    sf: sf
    sync_words: '18'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'False'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: freq_stop - freq_start
    fc: (freq_stop + freq_start) / 2
    fftsize: '2048'
    int_max: '0'
    type: complex
    update_time: '0.001'
    wintype: window.WIN_HAMMING
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    bandwidth: bandwidth
    center_freq: freq_center
    dev_args: uri=ip:192.168.2.1
    gain: '50'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: message
  states: {}

connections:
- [blocks_message_strobe_0, strobe, epy_block_1, msg_in]
- [epy_block_0, msg_out, epy_block_3, msg_in]
- [epy_block_1, msg_out, virtual_sink_1, '0']
- [epy_block_3, cmd_out, soapy_plutosdr_sink_0, cmd]
- [iio_pluto_source_0, '0', lora_rx_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', virtual_sink_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [virtual_source_0, '0', soapy_plutosdr_sink_0, '0']
- [virtual_source_1, '0', epy_block_0, msg_in]
- [virtual_source_1, '0', lora_sdr_whitening_0, msg]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
