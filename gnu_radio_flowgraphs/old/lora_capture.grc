options:
  parameters:
    author: gabriel
    generate_options: qt_gui
    id: lora_capture
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 125000 * 1
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: freq_start
  id: variable
  parameters:
    value: '903500000'
  states: {}
- name: freq_stop
  id: variable
  parameters:
    value: '925900000'
  states: {}
- name: freq_temp
  id: variable
  parameters:
    value: '926000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bandwidth * 2
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int((freq_stop - freq_start) * 1.1)
    bbdc: 'True'
    buffer_size: '327680'
    filter_source: '''Auto'''
    frequency: (freq_stop + freq_start) // 2
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: bandwidth
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: samp_rate
    sf: '7'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: freq_stop - freq_start + (samp_rate * 2)
    fc: (freq_start + freq_stop) / 2
    fftsize: '256'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: freq_temp - freq_start
    fc: (freq_start + freq_stop) // 2
    fftsize: '256'
    type: complex
    update_time: '0.001'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: (freq_stop - freq_start)
    fc: (freq_start + freq_stop) // 2
    fftsize: '512'
    type: complex
    update_time: '0.00001'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_tx_0, in]
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [lora_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [lora_tx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
