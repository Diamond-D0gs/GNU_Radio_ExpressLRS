options:
  parameters:
    generate_options: qt_gui
    id: elrs_transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 125000 * 1
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: freq_center
  id: variable
  parameters:
    value: (freq_stop + freq_start) / 2
  states: {}
- name: freq_start
  id: variable
  parameters:
    value: '903500000'
  states: {}
- name: freq_stop
  id: variable
  parameters:
    value: '925900000'
  states: {}
- name: freq_temp
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bandwidth*2
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: freq_stop - freq_start
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: crc
  states: {}
- name: lora_sdr_frequency_hopping_sender_0
  id: lora_sdr_frequency_hopping_sender
  parameters:
    binding_phrase: DefaultBindingPhrase
    freq_count: '40'
    freq_start: freq_start
    freq_stop: freq_stop
  states: {state: disabled}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: crc
    impl_head: 'False'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: '0'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bandwidth
    frame_zero_padd: int(20*2**sf*samp_rate/bandwidth)
    preamb_len: '8'
    samp_rate: samp_rate
    sf: sf
    sync_words: '18'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'False'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: wide_samp_rate / samp_rate
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate / wide_samp_rate
    type: ccf
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: freq_stop - freq_start
    fc: (freq_stop + freq_start) / 2
    fftsize: '512'
    int_max: '0'
    type: complex
    update_time: '0.001'
    wintype: window.WIN_HAMMING
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_divide_xx_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [blocks_message_strobe_0, strobe, lora_sdr_frequency_hopping_sender_0, Packet_data_in]
- [blocks_message_strobe_0, strobe, lora_sdr_whitening_0, msg]
- [blocks_multiply_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_frequency_hopping_sender_0, Packet_data_out, lora_sdr_frequency_hopping_sender_0, Packet_data_in]
- [lora_sdr_frequency_hopping_sender_0, Packet_data_out, lora_sdr_whitening_0, msg]
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', virtual_sink_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', lora_rx_0, '0']
- [virtual_source_0, '0', pfb_arb_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
