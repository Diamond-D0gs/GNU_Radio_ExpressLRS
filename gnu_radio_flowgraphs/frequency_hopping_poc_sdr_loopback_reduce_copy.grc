options:
  parameters:
    generate_options: qt_gui
    id: elrs_transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 8000 * 1
  states: {}
- name: binding_phrase
  id: variable
  parameters:
    value: '"TestBindingPhrase"'
  states: {}
- name: counter
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: disable
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: freq_center
  id: variable
  parameters:
    value: '914700000'
  states: {}
- name: freq_count
  id: variable
  parameters:
    value: '8'
  states: {}
- name: freq_start
  id: variable
  parameters:
    value: freq_center - 100000
  states: {}
- name: freq_stop
  id: variable
  parameters:
    value: freq_center + 100000
  states: {}
- name: freq_temp
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bandwidth*2
  states: {}
- name: sdr_buffer_size
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: sdr_samp_rate
  id: variable
  parameters:
    value: wide_samp_rate
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: wide_samp_rate
  id: variable
  parameters:
    value: freq_stop - freq_start
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_temp
    offset: '0'
    phase: '0'
    samp_rate: wide_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("")
    period: '1000'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_temp
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr
      from hashlib import md5

      class fhss_controller(gr.sync_block):
          # This is the corrected line with default values
          def __init__(self, binding_phrase="", freq_start=0.0, freq_stop=0.0, freq_count=1, freq_center=0.0, disable=False):
              gr.sync_block.__init__(self,
                  name='FHSS Controller',
                  in_sig=None,
                  out_sig=None)
              
              # Store parameters passed from GRC
              self.binding_phrase = binding_phrase
              self.freq_start = freq_start
              self.freq_stop = freq_stop
              self.freq_count = freq_count
              self.freq_center = freq_center
              self.disable = disable

              # Register message ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              # --- Setup logic from your script ---
              self.FHSS_SEQUENCE_LEN = 256
              self.OTA_VERSION_ID = 6
              
              if self.freq_count > 1:
                  self.freq_spread = abs(self.freq_stop - self.freq_start) // (self.freq_count - 1)
              else:
                  self.freq_spread = 0 # Provide a safe default

              # Add another check for the next line
              if self.freq_count > 0:
                  self.num_primary_bands = (self.FHSS_SEQUENCE_LEN // self.freq_count) * self.freq_count
              else:
                  self.num_primary_bands = 0 # Provide a safe default

              uid_bytes = md5(self.binding_phrase.encode()).digest()[0:6]
              self.seed = (uid_bytes[2] << 24) | (uid_bytes[3] << 16) | (uid_bytes[4] << 8) | (uid_bytes[5] ^ self.OTA_VERSION_ID)
              self.freq_sequence = [0] * self.FHSS_SEQUENCE_LEN
              self.fhss_index = 0
              
              self.build_random_fhss_sequence()

          def elrs_rng(self):
              self.seed = (0x343FD * self.seed + 0x269EC3) % 0x80000000
              return self.seed >> 16
          
          def build_random_fhss_sequence(self):
              # Only build if freq_count is valid
              if self.freq_count < 2: return

              for i in range(self.num_primary_bands):
                  self.freq_sequence[i] = i % self.freq_count
              
              for i in range(1, self.num_primary_bands):
                   if (i % self.freq_count) != 0:
                      offset = (i // self.freq_count) * self.freq_count
                      rand = (self.elrs_rng() % (self.freq_count - 1)) + 1
                      self.freq_sequence[i], self.freq_sequence[offset + rand] = self.freq_sequence[offset + rand], self.freq_sequence[i]

          def handle_msg(self, msg):
              if not self.disable:
                  current_freq_index = self.freq_sequence[self.fhss_index]
                  absolute_freq = self.freq_start + (current_freq_index * self.freq_spread)
                  freq_offset = absolute_freq - self.freq_center

                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(freq_offset + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)
                  
                  self.fhss_index = (self.fhss_index + 1) % self.freq_count
              else:
                  key = pmt.intern("freq_temp")
                  value = pmt.from_double(self.freq_center + 3.7e6) # Temp fix
                  output_msg = pmt.cons(key, value)

                  self.message_port_pub(pmt.intern("msg_out"), output_msg)


          def work(self, input_items, output_items):
              return 0
    binding_phrase: binding_phrase
    disable: disable
    freq_center: freq_center
    freq_count: freq_count
    freq_start: freq_start
    freq_stop: freq_stop
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr

      class counter_formatter(gr.sync_block):
          """
          Receives a trigger message. On each trigger, it formats a string
          with the value of a 'counter' variable from the top_block,
          sends it as a new message, and increments the counter.
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                  name='Counter Formatter',
                  in_sig=None,
                  out_sig=None)

              self.counter = 0
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("msg_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Format the string using the flowgraph's 'counter' variable
              # Note: self.counter works because the 'counter' Variable block
              # creates a 'self.counter' attribute on the main flowgraph class.
              payload_str = "TEST " + str(self.counter)

              # 2. Create the new PMT message
              output_msg = pmt.intern(payload_str)

              # 3. Publish the new message
              self.message_port_pub(pmt.intern("msg_out"), output_msg)
              
              # 4. Increment the counter for the next time
              self.counter += 1

          def work(self, input_items, output_items):
              # This block only processes messages, so work() does nothing.
              return 0
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: sdr_samp_rate
    buffer_size: sdr_buffer_size
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq_center)
    samplerate: sdr_samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: sdr_samp_rate
    bbdc: 'True'
    buffer_size: sdr_buffer_size
    filter_source: '''Auto'''
    frequency: int(freq_center)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sdr_samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: crc
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: crc
    impl_head: 'False'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: '0'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bandwidth
    frame_zero_padd: int(20*2**sf*samp_rate/bandwidth)
    preamb_len: '8'
    samp_rate: samp_rate
    sf: sf
    sync_words: '18'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'False'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: freq_stop - freq_start
    fc: (freq_stop + freq_start) / 2
    fftsize: '512'
    int_max: '0'
    type: complex
    update_time: '0.0001'
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '25'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: unshifted_lora
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: message
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: shift_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: unshifted_lora
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: message
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: shift_signal
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: shift_signal
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_sig_source_x_0, '0', virtual_sink_3, '0']
- [blocks_divide_xx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_message_strobe_0, strobe, epy_block_1, msg_in]
- [blocks_multiply_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_multiply_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_0, msg_out, blocks_msgpair_to_var_0, inpair]
- [epy_block_1, msg_out, virtual_sink_1, '0']
- [iio_pluto_source_0, '0', blocks_divide_xx_0, '1']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', virtual_sink_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_1, '0', lora_rx_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_1, '0', epy_block_0, msg_in]
- [virtual_source_1, '0', lora_sdr_whitening_0, msg]
- [virtual_source_2, '0', blocks_multiply_xx_0, '1']
- [virtual_source_2_0, '0', blocks_divide_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
