options:
  parameters:
    generate_options: qt_gui
    id: elrs_listener
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_center
  id: variable
  parameters:
    value: (freq_start + freq_stop) // 2
  states: {}
- name: freq_range
  id: variable
  parameters:
    value: freq_stop - freq_start
  states: {}
- name: freq_start
  id: variable
  parameters:
    value: '903500000'
  states: {}
- name: freq_stop
  id: variable
  parameters:
    value: '925900000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(freq_range * 1.1)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq_center
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(freq_range * 1.1)
    fc: freq_center
    fftsize: '4096'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
