options:
  parameters:
    author: gabriel
    generate_options: qt_gui
    id: synchronization
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: period
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.init_u8vector(1, 0x01)
    period: '100'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: elrs_module_elrs_receiver_0
  id: elrs_module_elrs_receiver
  parameters:
    binding_phrase: '"DefaultBindingPhrase"'
    domain: '"FCC915"'
    packet_rate: '25'
  states: {state: disabled}
- name: elrs_module_elrs_transmitter_0
  id: elrs_module_elrs_transmitter
  parameters:
    binding_phrase: '"DefaultBindingPhrase"'
    domain: '"FCC915"'
    packet_rate: '25'
  states: {state: disabled}
- name: lora_sdr_lora_rx_mod_0
  id: lora_sdr_lora_rx_mod
  parameters:
    bw: '125000'
    center_freq: '868100000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro_mode: '2'
    pay_len: '255'
    samp_rate: '250000'
    sf: '7'
    soft_decoding: 'False'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: lora_sdr_lora_tx_mod_0
  id: lora_sdr_lora_tx_mod
  parameters:
    bw: '125000'
    cr: '1'
    frame_zero_padd: 2**7
    has_crc: 'True'
    impl_head: 'False'
    ldro_mode: '2'
    samp_rate: '250000'
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 926900000 - 903500000
    fc: '915000000'
    fftsize: '512'
    int_max: '0'
    type: complex
    update_time: '0.001'
    wintype: window.WIN_HAMMING
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_sdr_lora_tx_mod_0, in]
- [blocks_null_source_0, '0', elrs_module_elrs_transmitter_0, '0']
- [elrs_module_elrs_receiver_0, '0', blocks_null_sink_0, '0']
- [elrs_module_elrs_transmitter_0, '0', blocks_null_sink_0_0, '0']
- [elrs_module_elrs_transmitter_0, '0', elrs_module_elrs_receiver_0, '0']
- [elrs_module_elrs_transmitter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [lora_sdr_lora_rx_mod_0, out, blocks_message_debug_0, print]
- [lora_sdr_lora_tx_mod_0, '0', lora_sdr_lora_rx_mod_0, '0']
- [lora_sdr_lora_tx_mod_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
