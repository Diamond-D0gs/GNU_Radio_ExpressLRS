options:
  parameters:
    author: gabriel
    generate_options: qt_gui
    id: synchronization
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: period
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: elrs_module_elrs_receiver_0
  id: elrs_module_elrs_receiver
  parameters:
    binding_phrase: '"DefaultBindingPhrase"'
    domain: '"FCC915"'
    packet_rate: '25'
  states: {}
- name: elrs_module_elrs_transmitter_0
  id: elrs_module_elrs_transmitter
  parameters:
    binding_phrase: '"DefaultBindingPhrase"'
    domain: '"FCC915"'
    packet_rate: '25'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 926900000 - 903500000
    fc: '915000000'
    fftsize: '512'
    int_max: '0'
    type: complex
    update_time: '0.001'
    wintype: window.WIN_HAMMING
  states: {}

connections:
- [blocks_null_source_0, '0', elrs_module_elrs_transmitter_0, '0']
- [elrs_module_elrs_receiver_0, '0', elrs_module_elrs_transmitter_0, '0']
- [elrs_module_elrs_transmitter_0, '0', blocks_null_sink_0, '0']
- [elrs_module_elrs_transmitter_0, '0', elrs_module_elrs_receiver_0, '0']
- [elrs_module_elrs_transmitter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
