options:
  parameters:
    author: gabriel
    generate_options: qt_gui
    id: binary_mod_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: test
  id: variable
  parameters:
    value: '''TEST''.encode()'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.init_u8vector(len(test), list(test))
    period: '1000'
  states: {state: disabled}
- name: lora_sdr_lora_rx_mod_0
  id: lora_sdr_lora_rx_mod
  parameters:
    bw: '125000'
    center_freq: '868100000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '0'
    pay_len: '255'
    samp_rate: '250000'
    sf: '7'
    soft_decoding: 'False'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: lora_sdr_lora_tx_mod_0
  id: lora_sdr_lora_tx_mod
  parameters:
    bw: '125000'
    cr: '1'
    frame_zero_padd: '128'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '0'
    samp_rate: '250000'
    sf: '7'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: lora_sdr_lora_tx_mod_1
  id: lora_sdr_lora_tx_mod
  parameters:
    bw: '125000'
    cr: '1'
    frame_zero_padd: '128'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '2'
    samp_rate: '250000'
    sf: '7'
    sync_word: '[0x12]'
  states: {}
- name: mock_elrs_sender_0
  id: mock_elrs_sender
  parameters:
    binding_phrase: DefaultBindingPhrase
    center_freq: '915000000'
    filepath: /home/gabriel/GNU_Radio_ExpressLRS/test.txt
    freq_count: '40'
    packet_hop_interval: '2'
    packet_rate: '25'
    start_freq: '903500000'
    stop_freq: '926900000'
    timing_adjust: '1.0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_sdr_lora_tx_mod_0, in]
- [lora_sdr_lora_rx_mod_0, out, blocks_message_debug_0, print]
- [lora_sdr_lora_tx_mod_0, '0', lora_sdr_lora_rx_mod_0, '0']
- [lora_sdr_lora_tx_mod_1, '0', qtgui_waterfall_sink_x_0, '0']
- [mock_elrs_sender_0, out, lora_sdr_lora_tx_mod_1, in]

metadata:
  file_format: 1
